<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>DRIVER</name>
    <file>
      <name>$PROJ_DIR$\..\USER\src\EEPROM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\src\fdc2214.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\src\keyled.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\src\ntc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\src\uart.c</name>
    </file>
  </group>
  <group>
    <name>FWLib</name>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_adc1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_uart1.c</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\..\USER\src\main.c</name>
    </file>
  </group>
</project>


